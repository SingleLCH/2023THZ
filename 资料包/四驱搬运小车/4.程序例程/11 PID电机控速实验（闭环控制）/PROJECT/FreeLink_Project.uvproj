# Keil uVision project FreeLink_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeLink +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\ADC;..\USER;..\HARDWARE\USART;..\DEVICE\BEEP;..\DEVICE\ENCODER;..\DEVICE\MOTOR;..\DEVICE\OLED;..\DEVICE\PS2;..\DEVICE\RC;..\DEVICE\BLUETOOTH
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ../USER/: main.c Control.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
  group DEVICE
    ../DEVICE/ENCODER/: encoder.c
    ../DEVICE/MOTOR/: motor.c
    ../DEVICE/OLED/: oled.c oled_user.c
