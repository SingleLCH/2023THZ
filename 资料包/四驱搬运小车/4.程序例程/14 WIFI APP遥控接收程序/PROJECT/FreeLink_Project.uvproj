# Keil uVision project FreeLink_Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FreeLink +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\STMFLASH;..\HARDWARE\DMA;..\HARDWARE\ADC;..\USER;..\HARDWARE\USART;..\DEVICE\OLED;..\DEVICE\ESP8266
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/: startup_stm32f10x_hd.s
  group HARDWARE
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/DMA/: dma.c
  group DEVICE
    ../DEVICE/OLED/: oled.c oled_user.c
    ../DEVICE/ESP8266/: esp8266.c
