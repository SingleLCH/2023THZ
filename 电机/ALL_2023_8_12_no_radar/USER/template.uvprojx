# Keil uVision project template.uvprojx, settings and files
target TEMPLATE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\TOUCH;..\USMART;..\HARDWARE\TIMER;..\GUI;..\HARDWARE\MATH;..\HARDWARE\MPU;..\HARDWARE\PCF8574;..\HARDWARE\PROTOCOL;..\HARDWARE\QSPI;..\HARDWARE\RADAR;..\HARDWARE\STEPPER_MOTOR;..\GUI\lvgl\examples\porting;..\GUI\lvgl\src\core;..\GUI\lvgl\src\draw;..\GUI\lvgl\src\extra;..\GUI\lvgl\src\font;..\GUI\lvgl\src\hal;..\GUI\lvgl\src\misc;..\GUI\lvgl\src\widgets;..\GUI\lvgl;..\GUI;..\BG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c gt9271.c ott2001a.c touch.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MATH/: HANA_math.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/PROTOCOL/: protocol.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/RADAR/: radar.c
    ../HARDWARE/STEPPER_MOTOR/: stepper_motor.c
  group GUI/porting
    ../GUI/lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
  group GUI/src/core
    ../GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group GUI/src/draw
    ../GUI/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../GUI/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../GUI/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../GUI/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group GUI/src/extra
    ../GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../GUI/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../GUI/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../GUI/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../GUI/lvgl/src/extra/others/msg/: lv_msg.c
    ../GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../GUI/lvgl/src/extra/: lv_extra.c
  group GUI/src/font
    ../GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group GUI/src/hal
    ../GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group GUI/src/misc
    ../GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group GUI/src/widgets
    ../GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group BG
    ../BG/: ll.c MM.c THZ.c qrcode.c Ceramic.c metal.c water.c
